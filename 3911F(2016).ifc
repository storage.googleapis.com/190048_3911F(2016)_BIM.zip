Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-20T11:15:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 20 11:15:44 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{B7EF7EAE-CBC0-4799-8967-F081D39FD4DC}\ifc * Database version: 5507 * Database creation date: Wed Mar 20 11:15:43 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 20 11:15:43 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 20 11:15:43 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3911F Washbasin faucet, 3911F(2016):3911F Washbasin faucet:321314
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 144.3 mm; NominalHeight: 157 mm; NominalWidth: 49 mm; Projection: 110 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3911F(2016); ConvergoRefNr: 0087-1803-0032-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/03/2019
Type - Green Building Properties(Type) - Approval ABP: P-IX 28365/IA; Approval KIWA SE Type Approval: 1413; Customs Code: 84818011; EAN Number: 6414150077838; EN Standard: EN 817; NRF Number: 4200179; RSK Number: 8277666; URL ABP: http://static.oras.com/ABP/3911F; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3911F; VVS Number: 701241504
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3911F; Catalog Drawing URL: http://static.oras.com/catdrw/3911F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3911F; FDV Document URL: http://www.oras.com/datasheet/3911F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3911F; Group: Washbasin faucet; Long Marketing: Washbasin faucet with high swivel spout. There are also in-built limitation options for water temperature and maximum flow-rate. Flow controller 6.0 l/min. F= with flexible pipes; Manufacturer: Oras; Market: INT;NOR;SWE;DNK;POL;RUS;EST;LVA;UKR;LTU; Model: 3911F Washbasin faucet; Name_en: 3911F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Package Weight: 1.189 kg; Product Code: 3911F; Product Datasheet: http://www.oras.com/datasheet/3911F; Product Family: Oras Saga XL; Product Image URL: http://static.oras.com/image/3911F; Product URL: http://static.oras.com/3911F; Type Name: 3911F Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/3911F; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Noise Class: I (ISO 3822) Oras lab.; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.oras.com/sp/3911F; Spout Swivel Range: 120° (360°); Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3911F(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3911F; Name: 3911F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x145x250 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3911F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3911F Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0384976 m2; Volume: 0.00111404 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3911F(2016): 3911F Washbasin faucet; Family and Type: 3911F(2016): 3911F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3911F(2016): 3911F Washbasin faucet; Type Id: 3911F(2016): 3911F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
